# IAR project SeekFree_LPC546XX.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54606J512 NXP LPC54606J512
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: ..\..\USER\inc; ..\..\USER\src; ..\..\..\Libraries\startup\CoreSupport; ..\..\..\Libraries\startup\DeviceSupport\IAR-ARM; ..\..\..\Libraries\startup\DeviceSupport; ..\..\..\Libraries\drives\inc; ..\..\..\Libraries\seekfree; ..\..\..\Libraries\drives\common; ..\..\CODE; ..\..\..\Libraries\My_lib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SeekFree_LPC546XX.srec
  ILINK.IlinkOutputFile: SeekFree_LPC546XX.out
  ILINK.IlinkIcfFile: SeekFree_LPC546XX.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group drives/common
    ../../../Libraries/drives/common/: assert.c assert.h common.c common.h misc.c misc.h SEEKFREE_PRINTF.c SEEKFREE_PRINTF.h
  group drives/inc
    ../../../Libraries/drives/inc/: LPC546XX_adc.h LPC546XX_ctimer.h LPC546XX_dma.h LPC546XX_eeprom.h LPC546XX_flexcomm.h LPC546XX_gint.h LPC546XX_gpio.h LPC546XX_iic.h LPC546XX_iocon.h LPC546XX_mrt.h LPC546XX_pint.h LPC546XX_pit.h LPC546XX_pll.h LPC546XX_sct.h LPC546XX_spi.h LPC546XX_systick.h LPC546XX_uart.h
  group drives/src
    ../../../Libraries/drives/src/: LPC546XX_adc.c LPC546XX_ctimer.c LPC546XX_dma.c LPC546XX_eeprom.c LPC546XX_flexcomm.c LPC546XX_gint.c LPC546XX_gpio.c LPC546XX_iic.c LPC546XX_iocon.c LPC546XX_mrt.c LPC546XX_pint.c LPC546XX_pit.c LPC546XX_pll.c LPC546XX_sct.c LPC546XX_spi.c LPC546XX_systick.c LPC546XX_uart.c
  group My_lib
    ../../../Libraries/My_lib/: ANO_TC_CP.c ANO_TC_CP.h Car_Ctrl.c Car_Ctrl.h Connection_M.c Connection_M.h Data_defines.h Init.c Init.h Lab1349_Barcode_Scanner.c Lab1349_Barcode_Scanner.h Lab1349_OpenMV.c Lab1349_OpenMV.h Lab1349_Ops9.c Lab1349_Ops9.h Lab1349_ServoMotor.c Lab1349_ServoMotor.h Map.c Map.h Motor.c Motor.h My_Math.c My_Math.h Parameter.h WS2812B.c WS2812B.h
  group seekfree
    ../../../Libraries/seekfree/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_7725.c SEEKFREE_7725.h SEEKFREE_FONT.c SEEKFREE_FONT.h SEEKFREE_FUN.c SEEKFREE_FUN.h SEEKFREE_ICM20602.c SEEKFREE_ICM20602.h SEEKFREE_IIC.c SEEKFREE_IIC.h SEEKFREE_IPS114_SPI.c SEEKFREE_IPS114_SPI.h SEEKFREE_IPS200_PARALLEL8.c SEEKFREE_IPS200_PARALLEL8.h SEEKFREE_L3G4200D.c SEEKFREE_L3G4200D.h SEEKFREE_MMA8451.c SEEKFREE_MMA8451.h SEEKFREE_MPU6050.c SEEKFREE_MPU6050.h SEEKFREE_MT9V032.c SEEKFREE_MT9V032.h SEEKFREE_NRF24L01.c SEEKFREE_NRF24L01.h SEEKFREE_OLED.c SEEKFREE_OLED.h SEEKFREE_VIRSCO.c SEEKFREE_VIRSCO.h
  group startup
    ../../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_LPC54606.s
    ../../../Libraries/startup/DeviceSupport/: system_LPC54606.c system_LPC54606.h
  group user_c
    ../../USER/src/: isr.c main.c
    ../../../Libraries/: version.txt 引脚功能说明.txt
  group user_h
    ../../../Libraries/drives/inc/: headfile.h
    ../../USER/inc/: isr.h LPC546XX_config.h
